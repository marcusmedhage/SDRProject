options:
  parameters:
    author: Stream
    generate_options: qt_gui
    id: Eigenvalue_detector_USRP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Number_of_channels
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: Threshold_range
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '50'
    value: '0'
  states: {}
- name: amplitude_noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 2.4e9
    step: 5e6
    stop: 2.5e9
    value: 2.45e9
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 80e6
    step: 1e6
    stop: 100e6
    value: 90e6
  states: {}
- name: channel_selector
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: Number_of_channels-1
    value: '1'
  states: {}
- name: correction
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '30'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amplitude_noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: 2**14
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: 2**14
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '16384'
  states: {}
- name: blocks_stream_to_vector_decimator_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate
    type: complex
    vec_rate: '10'
    vlen: 2**14
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    Pfa: '0.05'
    Smooth_fact: '30'
    Threshold_corr: correction
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport time\nimport matplotlib.pyplot as plt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, vectorSize=2**14, Pfa=0.05, Smooth_fact=5, Threshold_corr=1,sampling_rate=30e3,num_channels=4,channel=0,noise_amplitude=0.1):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Eigenvalue_detector_channels',\n            in_sig=[(np.complex64,vectorSize)],\n            out_sig=[(np.complex64,vectorSize), (np.float32,vectorSize)],\n        )\n        self.portName = 'messageOutput'\n        self.message_port_register_out(pmt.intern(self.portName))\n        self.vectorSize = vectorSize\n        self.Pfa = Pfa\n        self.Smooth_fact = Smooth_fact\n        self.Threshold_corr = Threshold_corr\n        self.sampling_rate=sampling_rate\n        self.num_channels=num_channels\n        self.channel=channel\n        self.noise_amplitude=noise_amplitude=0.1\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        #Hard-coding vaibles as program is buggy\n        #Size of the FFT\n        #vectorSize = 2**11\n        Ns= self.vectorSize       \n        signal=input_items[0][0]\n        channel_outputs_size=int(self.vectorSize/self.num_channels)\n        Ratio1=0\n        gamma=0\n        \n        # Perform FFT of the combined signal\n        fft_result = np.fft.fft(signal)\n        freq = np.fft.fftfreq(len(fft_result), 1.0 / self.sampling_rate)\n\n        # Divide the spectrum into n equal channels\n        n = int(self.num_channels) # Number of channels\n\n        total_frequency_range = max(freq) - min(freq)\n        channel_bandwidth = total_frequency_range / n\n\n        # Define the center frequencies of the n channels\n        center_frequencies = [min(freq) + (i + 0.5) * channel_bandwidth for i in range(n)]\n\n        # Create channels for each frequency range\n        channels = []\n        for center_frequency in center_frequencies:\n            channel = np.logical_and(freq >= center_frequency - channel_bandwidth / 2, freq < center_frequency + channel_bandwidth / 2)\n            channels.append(channel)\n\n        # Apply FFT results to each channel\n        fft_channels = []\n        for i in range(n):\n            fft_channel = np.copy(fft_result)\n            #white_noise = np.mean(np.abs(fft_result)) * np.random.randn(len(signal))\n            fft_channel[~channels[i]] = 0  # Add white noise to frequencies outside of the channel\n            #fft_channel=fft_channel+white_noise\n            fft_channels.append(fft_channel)\n\n        # Perform Inverse FFT on each channel\n        reconstructed_signals = [np.fft.ifft(fft_channels[i]) for i in range(n)]\n        noise_reconstructed=np.random.randn(len(reconstructed_signals[0]))*0.003\n        reconstructed_signals=reconstructed_signals[:]+noise_reconstructed\n        #signal=reconstructed_signals[int(self.channel)] \n        active_channel_list=[]\n        for ii in range(n):\n            signal=reconstructed_signals[ii]\n          \n            #Pfa = 0.05  # Probability of false alarm\n            pd = 1 - self.Pfa\n\n            # Tracey-Widom dist\n            xi = np.array([-3.9, -3.18, -2.78, -1.91, -1.27, -0.59, 0.45, 0.98, 2.02])\n            yi = np.array([0.01, 0.05, 0.1, 0.3, 0.5, 0.7, 0.9, 0.95, 0.99])\n\n            # Find the index where the value in 'yi' is closest to 'pd'\n            Tracy_Widom_table_index = np.argmin(np.abs(yi - pd))\n\n            Tracy_Widom_value = xi[Tracy_Widom_table_index]\n\n            # Number of transmitters and receivers\n            M = 1\n            P = 1\n\n            N = 1\n            L = self.Smooth_fact  # Smoothing factor\n\n            # Finding the \"smoothed\" received signal\n            #X_hat = np.zeros((M * L, Ns))\n            #for k in range(L, Ns):\n            #    for l in range(1, L + 1):\n            #        X_hat[M * l - M:l * M, k] = signal[k - l + 1]\n            \n            X_hat = np.zeros((M*L,Ns-L))\n            for k in range(0,L):\n                X_hat[k,:] = signal[L-k:Ns-k]\n                \n            \n            R = np.matmul(X_hat, np.transpose(X_hat))\n            R /= Ns\n\n            # Eigenvalues\n            EIG = np.linalg.eigvals(R)\n            Lambda_max = max(EIG)\n            Lambda_min = min(abs(EIG))\n#             print(\"Max eigenvalue: \", Lambda_max)\n#             print(\"Min eigenvalue: \", Lambda_min)\n            \n            if Lambda_min==0:\n                detected_signal=\"Detected signal(eigenvalue is zero)\"\n                active_channel_list.append(\"1\")                \n            else:\n                \n               # Finds Ratio for MME Detection\n               Ratio1 = Lambda_max / Lambda_min\n\n               # Find Ratio for EME Detection\n               # Ratio2 = AVG_PWR / Lambda_min\n               # Find threshold\n               A = np.sqrt(Ns) + np.sqrt(M * L)\n               B = np.sqrt(Ns) - np.sqrt(M * L)\n               C = Ns * M * L\n               r1 = (A**2) / (B**2)\n               r2 = 1 + (A**(-2/3) / C**(1/6)) * Tracy_Widom_value\n               gamma = self.Threshold_corr*(r1 * r2)\n               if gamma <=Ratio1:\n                  detected_signal=\"Detected signal\"\n                  active_channel_list.append(\"1\")\n                  for vectorIndex in range(len(output_items[1])):\n                      for sampleIndex in list(range(channel_outputs_size*ii, channel_outputs_size*(ii+1))):\n                        output_items[1][vectorIndex][sampleIndex] = 20.0\n               else:\n                  detected_signal=\"No signal\"\n                  active_channel_list.append(\"0\")\n                  for vectorIndex in range(len(output_items[1])):\n                      for sampleIndex in list(range(channel_outputs_size*ii, channel_outputs_size*(ii+1))):\n                        output_items[1][vectorIndex][sampleIndex] = 0.01\n                \n            if int(self.channel)==ii:\n                print(\"The ratio for selected channel is: \",Ratio1)\n                print(\"The threshold is:\", gamma)\n            \n                             \n                \n\n\n    #         # Convert the signal array to a string\n    #         signal_str = ' '.join(map(str, signal))\n    #         \n    #         # Create a dictionary to hold both pieces of information\n    #         message_data = {'signal': signal_str, 'detected_signal': detected_signal}\n    #         print(\"Lambda_min:\", Lambda_min)\n    #         print(\"Ratio1:\", Ratio1)\n            #Printing:\n#                print(\"Ratio: \", Ratio1)\n#                print(\"Gamma: \",gamma)\n#                print(detected_signal)\n        # Convert the dictionary to a PMT message\n        compound_message = pmt.to_pmt(active_channel_list)\n        #output_items[0][0]=reconstructed_signals[int(self.channel)]\n        # Publish the compound message\n        self.message_port_pub(pmt.intern(self.portName), compound_message)\n        return len(output_items[0])\n\n\n\n\n"
    channel: channel_selector
    noise_amplitude: '0.01'
    num_channels: Number_of_channels
    sampling_rate: samp_rate
    vectorSize: '16384'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: 2**14
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2**14)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '8192'
    rate: '20'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    color1: '"red"'
    color2: '"blue"'
    grid: 'True'
    label1: Channel acitivation
    label2: FFT
    nconnections: '2'
    update_time: '0.05'
    vlen: '16384'
    width1: '4'
    x_axis_label: '"Frequency (MHz)"'
    x_start: (center_freq-samp_rate/2)/(1e6)
    x_step: (samp_rate/(1e6))/16384
    x_units: '"MHz"'
    y_axis_label: '""'
    ymax: '2'
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: center_freq
    gain0: '50'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_vector_decimator_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_stream_to_vector_decimator_0, '0', epy_block_1_0, '0']
- [blocks_stream_to_vector_decimator_0, '0', fft_vxx_0, '0']
- [epy_block_1_0, '0', blocks_null_sink_0, '0']
- [epy_block_1_0, '1', qtgui_vector_sink_f_0, '0']
- [epy_block_1_0, messageOutput, blocks_message_debug_0_0, log]
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [qtgui_sink_x_0, freq, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', blocks_add_xx_0, '1']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
